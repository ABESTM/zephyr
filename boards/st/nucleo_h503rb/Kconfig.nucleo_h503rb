## boards/st/nucleo_h503rb/Kconfig.nucleo_h503rb
```kconfig
# Copyright (c) 2019 STMicroelectronics
# SPDX-License-Identifier: Apache-2.0

config BOARD_NUCLEO_H503RB
	select SOC_STM32H503XX
```
